# IAR project MouseDemo.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: at91sam7s64 Atmel at91sam7s64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: at91sam7s64; flash; TRACE_LEVEL=3
  ICCARM.CCDiagSuppress: Pe826,Pe1375,Pa082
  ICCARM.CCIncludePath2: ..\at91lib/peripherals; ..\at91lib/components; ..\at91lib; ..\external_libs; ..\at91lib/boards/at91sam7s-ek
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam7s64; flash; TRACE_LEVEL=3
  AARM.AUserIncludes: ..\at91lib; ..\at91lib\peripherals; ..\at91lib\boards\at91sam7s-ek
  OBJCOPY.OOCOutputFile: MouseDemo.bin
  ILINK.IlinkOutputFile: MouseDemo.out
  ILINK.IlinkIcfFile: ..\at91lib\boards\at91sam7s-ek\at91sam7s64\flash
  ILINK.IlinkProgramEntryLabel: resetHandler
  group (top)
    ./: hid_enumerate.c main.c
  group at91lib/boards/at91sam7s-ek
    ../at91lib/boards/at91sam7s-ek/: board_cstartup_iar.s board_lowlevel.c board_memories.c
  group at91lib/peripherals/cp15
    ../at91lib/peripherals/cp15/: cp15.c cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../at91lib/peripherals/dbgu/: dbgu.c
  group at91lib/peripherals/irq
    ../at91lib/peripherals/irq/: aic.c
  group at91lib/peripherals/pio
    ../at91lib/peripherals/pio/: pio.c pio_it.c
  group at91lib/peripherals/pit
    ../at91lib/peripherals/pit/: pit.c
  group at91lib/peripherals/pmc
    ../at91lib/peripherals/pmc/: pmc.c
  group at91lib/usb/common/core
    ../at91lib/usb/common/core/: USBConfigurationDescriptor.c USBEndpointDescriptor.c USBFeatureRequest.c USBGenericDescriptor.c USBGenericRequest.c USBGetDescriptorRequest.c USBInterfaceRequest.c USBSetAddressRequest.c USBSetConfigurationRequest.c
  group at91lib/usb/common/hid
    ../at91lib/usb/common/hid/: HIDIdleRequest.c HIDReportRequest.c
  group at91lib/usb/device/core
    ../at91lib/usb/device/core/: USBD_OTGHS.c USBD_UDP.c USBD_UDPHS.c USBDCallbacks_Initialized.c USBDCallbacks_Reset.c USBDDriver.c USBDDriverCb_IfSettingChanged.c
  group at91lib/usb/device/hid-mouse
    ../at91lib/usb/device/hid-mouse/: HIDDMouseDriver.c HIDDMouseDriverDescriptors.c HIDDMouseInputReport.c
  group at91lib/utility
    ../at91lib/utility/: led.c trace.c
