# IAR project USB.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  ICCARM.CCDefines: ESS
  ICCARM.CCIncludePath2: srciar\; ..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: ..\..\include\
  XLINK.XclFile: resource\at91SAM7S64_16KRAM.xcl
configuration FLASH (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: resource\at91SAM7S64_NoRemap.xcl
configuration Bin (ARM, debug)
  as the first configuration, except:
  XLINK.XclFile: resource\at91SAM7S64_NoRemap.xcl
  XLINK.XExtraOptions: -YA
  group Cstartup
    SrcIAR/: Cstartup.s79 Cstartup_SAM7.c
  group Resource
    resource/: at91SAM7S64_16KRAM.xcl at91SAM7S64_NoRemap.xcl SAM7.mac SAM7_RAM.mac
  group USB
    ../src/: dbgu.c hid_enumerate.c main.c
